# Keil uVision project ble_app_template_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=1 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\..\..\..\..\..\remote\ble_peripheral\ble_app_template\pca10028\s110\arm5\RTE\nRF_Drivers\nRF51422_xxAC;..\..\..\..\..\..\..\..\remote\ble_peripheral\ble_app_template\pca10028\s110\arm5\RTE\nRF_BLE\nRF51422_xxAC;..\..\..\..\ble_app_template
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x1d000
  memory RVCT9: RAM 0x20002c00 size 0x2000
  group Application
    ../../../: main.c button_status.c rtt.c main.h
  group Documentation
    ../../../: Abstract.txt license.txt
  group RTT
    ../../../RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.1.0, Board Support:bsp 9.0.0, Board Support:bsp_btn_ble 9.0.0, Device:Startup 8.0.3, nRF_BLE:BLE_Modules:ble_advdata 3.0.1, nRF_BLE:BLE_Modules:ble_advertising 3.0.1, nRF_BLE:BLE_Modules:ble_common 3.0.1, nRF_BLE:BLE_Modules:ble_conn_params 3.0.1, nRF_BLE:BLE_Modules:ble_service_common 3.0.1, nRF_BLE:BLE_Modules:device_manager 3.0.1, nRF_BLE:BLE_Services:ble_bas 3.0.1, nRF_BLE:BLE_Services:ble_dfu 3.0.1, nRF_BLE:BLE_Services:ble_dis 3.0.1, nRF_Drivers:app_uart 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_drv_common 3.0.1, nRF_Drivers:nrf_drv_gpiote 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:nrf_gpiote 3.0.1, nRF_Drivers:pstorage 3.0.1, nRF_Libraries:DFU:dfu_app_handler 3.0.1, nRF_Libraries:DFU:dfu_bootloader_util 3.0.1, nRF_Libraries:app_button 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_gpiote 3.0.1, nRF_Libraries:app_scheduler 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_timer_with_app_scheduler 3.0.1, nRF_Libraries:app_trace 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:nrf_assert 3.0.1, nRF_Libraries:retarget 3.0.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s110 8.0.2, nRF_SoftDevice:s110_hex 8.0.2, nRF_SoftDevice:softdevice_hex 1.1.4
