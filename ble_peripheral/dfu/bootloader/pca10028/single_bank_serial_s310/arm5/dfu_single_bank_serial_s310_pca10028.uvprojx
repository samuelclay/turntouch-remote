# Keil uVision project dfu_single_bank_serial_s310_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S310 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x5380
  memory RVCT10: RAM 0x20007F80 size 0x80
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0, nRF_Drivers:nrf_delay 3.1.0, nRF_SoftDevice:Internal:sd_handler_with_app_scheduler 1.1.5, nRF_Libraries:app_error 3.1.0, nRF_SoftDevice:Internal:softdevice_present 1.1.5, nRF_Libraries:DFU:dfu_bootloader 3.1.0, nRF_Libraries:app_scheduler 3.1.0, nRF_SoftDevice:s310 3.0.1, nRF_Libraries:app_util 3.1.0, nRF_Libraries:hci_transport 3.1.0, nRF_Drivers:nrf_error 3.1.0, nRF_BLE:BLE_Modules:ble_conn_params 3.1.0, nRF_Libraries:DFU:dfu_bootloader_util 3.1.0, nRF_BLE:BLE_Modules:ble_service_common 3.1.0, nRF_Libraries:DFU:dfu_transport 3.1.0, nRF_Libraries:crc16 3.1.0, nRF_Drivers:nrf_uarte 3.1.0, Board Support:bsp 10.0.0, nRF_Libraries:hci_slip 3.1.0, nRF_Drivers:pstorage 3.1.0, nRF_Drivers:nrf_drv_uart 3.1.0, nRF_Drivers:app_uart 3.1.0, nRF_BLE:BLE_Modules:ble_advdata 3.1.0, nRF_Drivers:nrf_gpio 3.1.0, nRF_SoftDevice:Internal:sd_common 1.1.5, nRF_Libraries:nrf_assert 3.1.0, nRF_Drivers:nrf_uart 3.1.0, nRF_Drivers:nrf_drv_common 3.1.0, nRF_Libraries:nordic_common 3.1.0, nRF_Libraries:app_timer 3.1.0, nRF_Libraries:hci_mem_pool 3.1.0, nRF_Libraries:app_timer_with_app_scheduler 3.1.0, nRF_Libraries:DFU:dfu_bootloader_settings 3.1.0, nRF_BLE:BLE_Modules:ble_common 3.1.0
