# IAR project experimental_ble_app_hrs_advertiser_s130_pca10028.ewp, settings and files
configuration nrf51422_xxac_s130 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10028; S130; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\bsp; ..\..\..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\..\..\components\drivers_nrf\pstorage; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: experimental_ble_app_hrs_advertiser_s130_pca10028.hex
  ILINK.IlinkOutputFile: experimental_ble_app_hrs_advertiser_s130_pca10028.out
  ILINK.IlinkIcfFile: experimental_ble_app_hrs_advertiser_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group Board Support
    ../../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Application
    ../../../: advertiser_beacon.c main.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/s130/doc/: s130_nrf51822_1.0.0-3.alpha_licence_agreement.txt
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
