# Keil uVision project ble_app_gzll_s130_pca10028.uvproj, settings and files
target nrf51422_xxac_s130 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S130 GAZELL_PRESENT SWI_DISABLE1 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\properitary_rf\gzll;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\softdevice\common\softdevice_handler
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: ble_app_gzll_device.c ble_app_gzll_hr.c ble_app_gzll_ui.c main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer_ble_gzll.c
    ../../../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Properitary_RF
    ../../../../../../components/properitary_rf/gzll/arm/: gzll_arm.lib
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s130/doc/: s130_nrf51822_1.0.0-3.alpha_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: as above
  output: s130_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
