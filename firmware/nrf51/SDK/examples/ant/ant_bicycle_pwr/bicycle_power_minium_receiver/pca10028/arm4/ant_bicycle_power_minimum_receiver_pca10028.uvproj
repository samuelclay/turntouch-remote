# Keil uVision project ant_bicycle_power_minimum_receiver_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD TRACE_UART TRACE_CALIBRATION TRACE_DATA_PAGE S210 BOARD_PCA10028 SWI_DISABLE0 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\config;..\..\include;..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\hal
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x7700
  group Application
    ../../: bicycle_power_rx.c main.c main_bicycle_power_rx.c retarget.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s210/doc/: s210_nrf51422_4.0.1_licence_agreement.txt
