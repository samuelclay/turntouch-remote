<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\iar\ant_bicycle_power_only_sensor_s210_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>